# Keil uVision project 15-2直流电机调速.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 15-2直流电机调速 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 15-2直流电机调速.c Timer0.c Timer0.h

# Keil uVision project 5-1计时器中断.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 5-1计时器中断 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 5-1计时器中断.c Timer0.c Timer0.h
